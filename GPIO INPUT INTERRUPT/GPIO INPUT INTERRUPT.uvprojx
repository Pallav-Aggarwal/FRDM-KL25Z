# Keil uVision project GPIO INPUT INTERRUPT.uvprojx, settings and files
target GPIO INPUT INTERRUPT (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GPIO INPUT INTERRUPT +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Main Source
    ./: main.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
